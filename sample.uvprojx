# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c GLCD.h GLCD_SPI_LPC1700.c IRQ.c
  group button_EXINT
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group Potenciometer
    ./potenciometer/: IRQ_potenciometer.c Lib_potenciometer.c Potenciometer.h
  group Joystick
    ./Joystick/: joystick.c joystick.h
  group timer
    ./timer/: funct_timer.c IRQ_timer.c lib_timer.c timer.h
  group movement
    ./movement/: lib_movement.c movement.h
  group menu
    ./menu/: menu.c menu.h
software components: CMSIS:CORE 5.0.2
